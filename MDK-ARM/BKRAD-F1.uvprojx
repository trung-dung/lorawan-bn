# Keil uVision project BKRAD-F1.uvprojx, settings and files
target BKRAD-F1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: BKRAD-F1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\USER-SRC\boards;..\USER-SRC\boards\NucleoL476;..\USER-SRC\boards\mcu\stm32\EEPROM_Emul\Core;..\USER-SRC\boards\mcu\stm32\EEPROM_Emul\Porting\STM32L4;..\USER-SRC\drivers;..\USER-SRC\system;..\USER-SRC\peripherals\gsm;..\USER-SRC\peripherals\soft-se;..\USER-SRC\peripherals;..\USER-SRC\radio;..\USER-SRC\mac;..\USER-SRC\mac\region;..\USER-SRC\apps\LoRaMac\classA\NucleoL476;..\USER-SRC\apps\LoRaMac\common;..\USER-SRC\common
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c stm32l4xx_ll_exti.c stm32l4xx_ll_crc.c stm32l4xx_ll_gpio.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers
    ../USER-SRC/drivers/: uart_driver.c spi_driver.c iwdg_driver.c systick_driver.c
  group Common
    ../USER-SRC/common/: common.c debug_hal.c
  group Utilities
    ../USER-SRC/boards/mcu/: utilities.c
    ../USER-SRC/peripherals/soft-se/: aes.c cmac.c soft-se.c
  group Board
    ../USER-SRC/boards/NucleoL476/: board.c delay-board.c eeprom-board.c gpio-board.c lpm-board.c rtc-board.c spi-board.c sx1276mb1mas-board.c sysIrqHandlers.c
    ../USER-SRC/boards/mcu/stm32/EEPROM_Emul/Core/: eeprom_emul.c
    ../USER-SRC/boards/mcu/stm32/EEPROM_Emul/Porting/STM32L4/: flash_interface.c
  group System
    ../USER-SRC/system/: delay.c eeprom.c fifo.c gpio.c nvmm.c systime.c timer.c
  group Peripherials
    ../USER-SRC/peripherals/: lcd.cpp extmem_hal.cpp sst25vf_spi.cpp nmea.c
    ../USER-SRC/peripherals/gsm/: serial_pipe_hal.cpp
  group Radio
    ../USER-SRC/radio/: radio.c sx1276.c
  group Mac
    ../USER-SRC/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c
    ../USER-SRC/mac/region/: Region.c RegionCommon.c RegionEU868.c
  group Applications
    ../USER-SRC/apps/: main.cpp task_watchdog.cpp task_display.cpp task_sensorSerial.cpp task_lora.cpp task_systemMonitor.cpp task_gnss.cpp main_loadconfig.cpp
    ../USER-SRC/apps/LoRaMac/common/: NvmCtxMgmt.c
software components: CMSIS:CORE 4.3.0
